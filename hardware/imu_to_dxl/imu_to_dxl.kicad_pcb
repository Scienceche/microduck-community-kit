# Repository Scienceche/microduck-community-kit

## KiCad design hardware/imu_to_dxl/imu_to_dxl.kicad_pcb

Parts:
C1: 100p; C0402; LCSC Part C106200
C2, C7, C8, C9, C12, C13, C14, C15, C16, C18, C19: 100nF/16V; C0402; LCSC Part C1525
C5: 22uF/6.3V; C0603; LCSC Part C59461
C6: 10uF/50V; C0805; Manufacturer Part CL21A106KBYQNNE; LCSC Part C2932476
C10, C11: 20pF/50V; C0402; LCSC Part C107000
C17: 27pF/50V; C0402; LCSC Part C107002
C20, C21: 1uF/10V; C0402; LCSC Part C106254
C22: 1nF/50V; C0402; LCSC Part C106205
CN1: B3B-EH-A(LF)(SN); CONN-TH_B3B-EH-A-LF-SN; not fitted
CN2: AMP175778/8283/A2007WV-3P; CONN-TH_B3B-PH-K-S; not fitted
D1: SMAJ36A; SMA_L4.4-W2.6-LS5.0-RD; LCSC Part C353452
D2: 5V ESD; SOD-323_L1.7-W1.3-LS2.5-BI; LCSC Part C19224
F1: PTC(40R); F0603; Manufacturer Part JK-SMD0603-001; LCSC Part C2687114
H1, H3: LAIL-PZ2.54-4P-L; pad-4; Manufacturer Part LAIL-PZ2.54-4P-L; LCSC Part C54950602; not fitted
H2: PZ254V-11-05P; pad-5; Manufacturer Part PZ254V-11-05P; LCSC Part C492404; not fitted
J1, J2, J3, J4: 1.8mm螺丝孔; pad; not fitted
L1: 10uH/920mA; IND-SMD_L3.0-W3.0_SWPA3010S; Manufacturer Part SWPA3015S100MT; LCSC Part C45403
LED1: GL0603UG01; LED0603-RD; Manufacturer Part GL0603UG01
Q1: MMBT3906; SOT-23; LCSC Part C727128
R1: 75K; R0402; LCSC Part C144737
R2, R10, R11, R12, R13, R17, R18, R21, R22, R23, R24, R25, R26: 51R; R0402; LCSC Part C137960
R3, R34: 100K; R0402; LCSC Part C25741
R4: 30K; R0402; LCSC Part C25776; not fitted
R5: 0R; R0603; LCSC Part C21189
R6: 24K; R0402; LCSC Part C138026
R7, R8, R15, R16, R19: 10K; R0402; LCSC Part C25744
R9, R32: 0R; R0402; LCSC Part C60485
R14: 1K; R0402; LCSC Part C11702
R20: 51R; R0402; LCSC Part C137960; not fitted
R27, R28, R30: 10k; R0402; LCSC Part C25744
R29: 20k; R0402; LCSC Part C25765
R31: 100k; R0402; LCSC Part C25741
R33: 0R; R0402_Jumper; LCSC Part C60485; not fitted
R35: 1M; R0402; LCSC Part C26083
U1: ETA2845S2G_C22362741; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; Manufacturer Part ETA2845S2G; LCSC Part C22362741
U2: GD32F303CCT6; LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL; Manufacturer Part GD32F303CCT6; LCSC Part C116151
U3: LSM6DSV16XTR; LGA-14_L3.0-W2.5-P0.50-BR; Manufacturer Part LSM6DSV16XTR; LCSC Part C5267406
U4: SN74LVC1G126DBVR; SOT-23-5; LCSC Part C46472327
U5: SN74LVC1G125DBV; SOT-23-5; LCSC Part C3040625
U6: ME6211C18M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; Manufacturer Part ME6211C18M5G-N; LCSC Part C236671
X1: XL2EL89CSI-111YLC-12M; CRYSTAL-SMD_4P-L3.2-W2.5-BL; Manufacturer Part XL2EL89CSI-111YLC-12M; LCSC Part C5280576

Connections:
+1.8VA: C21.2, R32.1, U6.5 (VOUT)
+3.3V: C1.2, C5.2, C7.2, C12.1, C13.2, C14.2, C16.2, C18.2, C19.2, C20.2, H1.1, H2.2, L1.2, Q1.2 (E), R1.2, R7.1, R8.2, R9.2, R15.2, R16.2, R20.2, R27.2, R30.2, R31.2, R33.2, U2.1 (VBAT), U2.24 (VDD_1), U2.36 (VDD_2), U2.48 (VDD_3), U3.5 (Vdd_IO), U4.5 (VCC), U5.5 (VCC), U6.1 (VIN), U6.3 (CE)
+BATT: C6.2, CN1.2, CN2.2, D1.1 (K), H3.4, R3.2, U1.5 (IN)
/DATA: CN1.3, CN2.1, F1.1
/DATA1: R5.2, R31.1, U4.4, U5.2
/DEBUG_LED: LED1.2 (A), U2.41 (PB5)
/DEBUG_RX: R7.2, R10.1, U2.43 (PB7)
/DEBUG_TX: R11.1, U2.42 (PB6)
/GD_OSCIN: C10.2, R35.2, U2.5 (PD0-OSCIN), X1.1
/GD_OSCOUT: C11.2, R35.1, U2.6 (PD1-OSCOUT), X1.3
/GD_RST: C8.2, R8.1, R14.1, U2.7 (NRST)
/GD_SWDCLK: R12.1, R15.1, U2.37 (PA14)
/GD_SWDIO: R13.1, R16.1, U2.34 (PA13)
/IMU_INT1: R25.2, U3.4 (INT1)
/IMU_INT2: R26.2, U3.9 (INT2)
/IMU_SPI_CLK: R22.2, U3.13 (SCL)
/IMU_SPI_CS: C17.2, R21.2, U3.12 (CS)
/IMU_SPI_MISO: R23.2, U3.1 (SDO/SA0)
/IMU_SPI_MOSI: R24.2, U3.14 (SDA)
/PA2_USART1_TX: R27.1, R28.1, U2.12 (PA2), U4.2
/PA3_USART1_RX: R30.1, U2.13 (PA3), U5.4
/PA4_SPI0_NSS: R21.1, U2.14 (PA4)
/PA5_SPI0_SCK: R22.1, U2.15 (PA5)
/PA6_SPI0_MISO: R23.1, U2.16 (PA6)
/PA7_SPI0_MOSI: R24.1, U2.17 (PA7)
/PB0: R25.1, U2.18 (PB0)
/PB1: R26.1, U2.19 (PB1)
/TXD_EN: C22.2, Q1.3 (C), R29.2, U4.1, U5.1
/USB_DM: H3.3, R17.2
/USB_DP: H3.2, R18.2
GND: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.2, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, CN1.1, CN2.3, D1.2 (A), D2.1, H1.2, H2.3, H3.1, R4.2, R6.1, R19.1, R29.1, R34.2, U1.2 (GND), U2.8 (VSSA), U2.23 (VSS_1), U2.35 (VSS_2), U2.47 (VSS_3), U3.2 (SDx/AH1/Qvar1), U3.3 (SCx/AH2/Qvar2), U3.6 (GND), U3.7 (GND), U4.3 (GND), U5.3 (GND), U6.2 (VSS), X1.2 (GND), X1.4 (GND)
unnamed: C2.1, R2.2
unnamed: D2.2, F1.2, R5.1
unnamed: H1.3, R10.2
unnamed: H1.4, R11.2
unnamed: H2.1, R14.2
unnamed: H2.4, R13.2
unnamed: H2.5, R12.2
unnamed: LED1.1 (K), R34.1
unnamed: Q1.1 (B), R28.2
unnamed: R2.1, U1.1 (BST)
unnamed: R3.1, R4.1, U1.4 (EN)
unnamed: C1.1, R1.1, R6.2, U1.3 (FB)
unnamed: C2.2, L1.1, U1.6 (SW)
unnamed: R19.2, R33.1, U2.44 (BOOT0)
unnamed: R17.1, U2.32 (PA11)
unnamed: R18.1, U2.33 (PA12)
unnamed: C9.2, R9.1, U2.9 (VDDA)
unnamed: C15.2, R20.1, R32.2, U3.8 (Vdd)

Notes on the sheet:
Debug
二选一，手工焊接
SWD
USB Download
USB Download Switch

Board: 2 copper layers, 27.1 x 30.2 mm, 77 parts (0 on the bottom side), 49 nets.

File hardware/imu_to_dxl/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,C0402,1,100p,C106200
"C10, C11",C0402,2,20pF/50V,C107000
"C12, C13, C14, C15, C16, C18, C19, C2, C7, C8, C9",C0402,11,100nF/16V,C1525
C17,C0402,1,27pF/50V,C107002
"C20, C21",C0402,2,1uF/10V,C106254
C22,C0402,1,1nF/50V,C106205
C5,C0603,1,22uF/6.3V,C59461
C6,C0805,1,10uF/50V,C2932476
D1,SMA_L4.4-W2.6-LS5.0-RD,1,SMAJ36A,C353452
D2,SOD-323_L1.7-W1.3-LS2.5-BI,1,5V ESD,C19224
F1,F0603,1,PTC(40R),C2687114
L1,IND-SMD_L3.0-W3.0_SWPA3010S,1,10uH/920mA,C45403
LED1,LED0603-RD,1,GL0603UG01,
Q1,SOT-23,1,MMBT3906,C727128
R1,R0402,1,75K,C144737
"R10, R11, R12, R13, R17, R18, R2, R21, R22, R23, R24, R25, R26",R0402,13,51R,C137960
R14,R0402,1,1K,C11702
"R15, R16, R19, R27, R28, R30, R7, R8",R0402,8,10K,C25744
R29,R0402,1,20k,C25765
"R3, R31, R34",R0402,3,100K,C25741
"R32, R9",R0402,2,0R,C60485
R35,R0402,1,1M,C26083
R5,R0603,1,0R,C21189
R6,R0402,1,24K,C138026
U1,SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR,1,ETA2845S2G_C22362741,C22362741
U2,LQFP-48_L7.0-W7.0-P0.50-LS9.0-BL,1,GD32F303CCT6,C116151
U3,LGA-14_L3.0-W2.5-P0.50-BR,1,LSM6DSV16XTR,C5267406
U4,SOT-23-5,1,SN74LVC1G126DBVR,C46472327
U5,SOT-23-5,1,SN74LVC1G125DBV,C3040625
U6,SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR,1,ME6211C18M5G-N,C236671
X1,CRYSTAL-SMD_4P-L3.2-W2.5-BL,1,XL2EL89CSI-111YLC-12M,C5280576
